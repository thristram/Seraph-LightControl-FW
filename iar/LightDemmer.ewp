# IAR project LightDemmer.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\driver\inc; ..\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LightDemmer.hex
  ILINK.IlinkOutputFile: LightDemmer.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 0
  ICCSTM8.CCDefines: NDEBUG; ENABLE_WDT
  OBJCOPY.OOCOutputFile: LightDimmer.hex
  postbuild: CopyHex.bat
  group driver
    ../driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group src
    ../src/: main.c main.h stm8s_conf.h stm8s_it.c stm8s_it.h
